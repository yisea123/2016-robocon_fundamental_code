# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: project +hex
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\..\Libraries\cmsis;..\..\Libraries\StdPeriph_Driver\inc;..\..\User\INC;..\..\Libraries\MY\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../../User/SRC/: main.c delay.c encoder.c pwm.c stm32f10x_it.c tim2.c usart2.c pid.c GlobalVars.c ad.c
  group LIB
    ../../Libraries/StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_spi.c
  group CMSIS
    ../../Libraries/cmsis/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ../../Libraries/startup/arm/: startup_stm32f10x_md.s
  group READ ME
    ../../: Read me.txt
